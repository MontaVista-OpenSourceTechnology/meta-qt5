PR .= ".1"

inherit multilib_script
MULTILIB_SCRIPTS = "${PN}:${bindir}/Qt5_CinematicExperience"
